# Keil uVision project uc1788.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uc1788
  c flags: Optim=1
  c include: ..\..\CMSISv2p00_LPC177x_8x\inc;..\..\LPC177x_8xLib\inc;..\..\Config;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\BoardSupport;..\App;..\..\YAFFS2;..\..\lwip\include;..\..\goahead\src;..\..\hvsftpd;..\..\User;..\..\Task;..\..\GuiLib\include;..\..\GuiLib\Config;..\..\FreeModbus\modbus\include;..\..\FreeModbus\port;..\..\FreeModbus;..\..\FreeModbus\modbus\rtu;..\..\Modbus;..\..\Modbus\master
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\FLASH.sct
  group Startup
    ../../CMSISv2p00_LPC177x_8x/src/: startup_LPC177x_8x.s system_LPC177x_8x.c
  group Core
    ../../CMSISv2p00_LPC177x_8x/src/: core_cm3.c
  group Drivers
    ../../LPC177x_8xLib/src/: lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_timer.c lpc177x_8x_emac.c lpc177x_8x_lcd.c lpc177x_8x_uart.c lpc177x_8x_exti.c lpc177x_8x_i2c.c
  group BoardSupport
    ../../BoardSupport/: sdram_mt48lc8m32lfb5.c norflash_sst39vf1601.c nandflash_k9f4g08u0b.c phylan_dm9161a.c SSP_GT21L16S2W.c GPIOConfig.c com_uart.c SSP_M25P128.c eeprom_st24c02.c
  group uCOS-II
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group uC/GUI
    ../../GuiLib/user/: GUI_X_uCOS-II.c
    ../../GuiLib/obj/: ucGui.lib
  group YAFFS2
    ../../YAFFS2/: yaffs_allocator.c yaffs_attribs.c yaffs_bitmap.c yaffs_checkptrw.c yaffs_ecc.c yaffs_guts.c yaffs_hweight.c yaffs_k9f4g08u0b.c yaffs_nameval.c yaffs_nand.c yaffs_nand_drv.c yaffs_packedtags2.c yaffs_qsort.c yaffs_summary.c yaffs_tagscompat.c yaffs_tagsmarshall.c yaffs_ucos_glue.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffscfg2k.c yaffsfs.c
  group lwip
    ../../lwip/: sys_arch.c
    ../../lwip/netif/: etharp.c slipif.c ethernetif.c
    ../../lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group App
    ../App/: app_hooks.c nand_test.c jlink_putc.c sct_test.c tcp_test.c emac_test.c
    ../../YAFFS2/: fs_test.c
  group User
    ../../User/: user_key.c user_BrowsTestpoint.c user_DispBackpower.c user_DispConnect.c user_main.c user_menu.c user_SetAddr.c user_SetConnect.c user_SetPassword.c user_SetTime.c user_SetType.c user_TestIO.c user_TestRS485.c user_TestSerial.c user_TestTotal.c user_UnitTest.c user_SaveOption.c user_file.c user_Correct.c user_ErrorRateRS485.c
    ../../GuiLib/GUI/Widget/: LISTVIEW.c MENU.c
  group Task
    ../../Task/: EquipmentList.c task_UartRcv.c Sensor_Operation.c
  group Image
    ../../Image/: G631Y2.c
  group goahead
    ../../goahead/src/: action.c alloc.c auth.c cgi.c crypt.c file.c fs.c goahead.c http.c js.c jst.c options.c osdep.c rom-documents.c route.c runtime.c socket.c upload.c
  group hvsftpd
    ../../hvsftpd/: cmd.c hfio.c hfsocket.c hvsftpd.c port.c session.c
  group FreeModbus
    ../../FreeModbus/modbus/rtu/: mbrtu_m.c mbcrc.c
    ../../FreeModbus/modbus/: mb_m.c
    ../../FreeModbus/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ../../FreeModbus/port/: FMBport.c portevent_m.c portserial_m.c porttimer_m.c user_mb_app_m.c
  group Modbus
    ../../Modbus/: MB_RTU.c MBCommon.c SYSHAL.C
    ../../Modbus/master/: MB_MFunction.c MBMaster.c OSFUNfile.c
target SDRAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: uc1788
  c flags: Optim=1
  c define: __RAM_MODE__
  c include: ..\..\CMSISv2p00_LPC177x_8x\inc;..\..\LPC177x_8xLib\inc;..\..\Config;..\..\uCOS-II\Source;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\BoardSupport;..\App;..\..\YAFFS2;..\..\lwip\include;..\..\goahead\src;..\..\hvsftpd;..\..\User;..\..\Task;..\..\GuiLib\include;..\..\GuiLib\config
  memory RVCT1: ROM 0xa0000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\SDRAM.sct
  link misc: --datacompressor off
